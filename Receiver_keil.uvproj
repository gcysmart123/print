# Keil uVision project Receiver_keil.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Receiver_keil +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Receiver
  group Source Group 1
    ./: STARTUP.A51
    ./Receiver/: main.c usart.c key.c tm1629.c timer.c ds1302.c ev1527.c decoder.c at24c256.c gd5800.c com.c printer.c pca.c
